# Keil uVision project c8t6_wsd.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: c8t6_wsd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Others\Led;.\Others\Exti;.\Others\Delay;.\Others\Pwm;.\Others\ty_uart;.\OLED;.\EncoderFile\sys;.\Others\tim;.\sht30;.\Others\dht11;.\mcu_sdk;.\Others\ty_key;.\Others\ty_rgb;.\Others\user_timer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_hd.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Others
    ./Others/Led/: Led.c
    ./Others/Exti/: Exti.c
    ./Others/Delay/: Delay.c
    ./Others/Pwm/: Pwm.c
    ./Others/dht11/: dht11.c
    ./Others/ty_uart/: ty_uart.c
    ./Others/ty_key/: Hal_Key.c
    ./Others/ty_rgb/: Hal_RGB.c
    ./Others/user_timer/: User_Timer.c
  group OLED
    ./OLED/: oled.c
  group EncoderFile
    ./EncoderFile/sys/: sys.c
  group sht30
    ./sht30/: i2c_hal.c sht3x.c system.c
  group mcusdk
    ./mcu_sdk/: mcu_api.c protocol.c system.c
